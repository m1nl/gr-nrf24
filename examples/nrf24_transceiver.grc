options:
  parameters:
    generate_options: qt_gui
    id: nrf24_transceiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel
  id: variable
  parameters:
    value: '8'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 320e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: (2400+channel)*1e6
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: int(8*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: channel_rate/symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (2*deviation+symbol_rate)/2
    gain: '1.0'
    samp_rate: samp_rate
    width: deviation
    win: window.WIN_BLACKMAN
  states: {}
- name: variable_qtgui_dial_control_0
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 0,2,1,1
    maximum: '82'
    minimum: '0'
    minsize: '82'
    showvalue: 'True'
    type: int
    value: '8'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: 1/preamble_length
    gate: 'True'
    ramp: int(sps*preamble_length)
    threshold: '-20'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate/(2*math.pi*deviation)
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: channel
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: int(sps)*2
    sensitivity: 1/(samp_rate/(2*math.pi*deviation))
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: 2 * math.pi * (1 / 20)
    max_dev: '0'
    osps: '1'
    pfb_mf_taps: firdes.gaussian(1.0, sps, 0.5, 4*int(sps))
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.9'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: nrf24_nrf24_decoder_b_0
  id: nrf24_nrf24_decoder_b
  parameters:
    address_size: '5'
    crc_size: '2'
  states: {}
- name: nrf24_nrf24_encoder_b_0
  id: nrf24_nrf24_encoder_b
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,0,1,3
    legend: 'False'
    size: 1024*int(sps)
    srate: channel_rate
    type: float
    ylabel: Deviation
    ymax: '+3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 2,0,1,3
    label1: Symbol
    label2: Error
    nconnections: '2'
    size: '1024'
    srate: symbol_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1.6e-4'
    type: float
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: symbol_rate+2*deviation
    center_freq: freq
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: symbol_rate+2*deviation
    center_freq: freq
    dev_args: driver=lime
    gain: '32'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9120
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:9121
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:9122
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', nrf24_nrf24_decoder_b_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_gfsk_mod_0, '0', soapy_limesdr_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [nrf24_nrf24_decoder_b_0, pdu, zeromq_pub_msg_sink_0, in]
- [nrf24_nrf24_encoder_b_0, '0', digital_gfsk_mod_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [variable_qtgui_dial_control_0, value, blocks_msgpair_to_var_0, inpair]
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_msg_source_0, out, nrf24_nrf24_encoder_b_0, pdu]
- [zeromq_sub_msg_source_1, out, soapy_limesdr_source_0, cmd]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
